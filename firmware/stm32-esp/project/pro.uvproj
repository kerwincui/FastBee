# Keil uVision project pro.uvproj, settings and files
target pro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: pro +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\libraries\cmsis\startup;..\libraries\fwlib\inc;..\libraries\cmsis;..\user;..\user\com;..\user\data;..\user\drive;..\user\show;..\user\cjson;..\user\mqtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../libraries/cmsis/startup/: startup_stm32f10x_hd.s
  group cmsis
    ../libraries/cmsis/: core_cm3.c system_stm32f10x.c
  group fwlib
    ../libraries/fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../user/: main.c stm32f10x_it.c main.h
  group user/drive
    ../user/drive/: bsp_adc.c bsp_clock.c bsp_port.c bsp_timer3.c bsp_tool.c bsp_uart1.c bsp_uart2.c bsp_uart3.c
  group user/com
    ../user/com/: uart1_receive.c uart2_receive.c uart3_receive.c
  group user/data
    ../user/data/: basic_data.c
  group user/show
    ../user/show/: battery.c dev_work.c esp8266_uart2.c esp8266_work.c pm_uart3.c simulation_lcd.c stmflash.c
  group user/cjson
    ../user/cjson/: cJSON.c
  group user/mqtt
    ../user/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
